# Keil uVision project LWIP.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LWIP +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\USER\LCD;..\USER\LED;..\USER\usart1;..\USER\KEY;..\USER\DP83848;..\USER\LWIP_APP;..\USER\usart;..\USER\CMD_HANDLE;..\USER\IWDG;..\USER\STMFLASH;..\USER\rtc;..\USER\tracking;..\FWLIB\STM32_ETH_Driver\inc;..\USER\auto_pid;..\ptpd-2.0.0\src;..\ptpd-2.0.0\src\dep;..\lwip-1.3.1\port;..\lwip-1.3.1\src\include\lwip;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\netif;..\USER\IRIG_B;..\FWLIB\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Main/: main.c task.c init.c stm32f10x_it.c
  group Startup_config
    ../Startup_config/: core_cm3.c stm32f107.c system_stm32f10x.c startup_stm32f107xc.s
  group USER
    ../USER/LED/: led.c
    ../USER/DP83848/: stm32f4x7_eth_bsp.c
    ../USER/usart/: usart.h usart.c
    ../USER/CMD_HANDLE/: cmd_handle.h cmd_handle.c bds.h bds.c
    ../USER/IWDG/: iwdg.h iwdg.c
    ../USER/STMFLASH/: stmflash.c
  group LWIP_APP
    ../USER/LWIP_APP/: netconf.c timer.h timer.c mktime.h mktime.c
    ../USER/IRIG_B/: irig_b.h irig_b.c
  group LWIP
    ../lwip-1.3.1/port/: ethernetif.c
    ../lwip-1.3.1/src/api/: api_msg.c api_lib.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/netif/: etharp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Common
    ../Common/: common.c
  group tracking
    ../USER/tracking/: filter.h filter.c pid.h pid.c dac.h dac.c lock.c Rubidium.c
  group ptpd
    ../ptpd-2.0.0/src/: arith.c bmc.c protocol.c ptpd.c
    ../ptpd-2.0.0/src/dep/: msg.c net.c servo.c startup.c sys_time.c timer.c
  group NTP
    ../USER/LWIP_APP/: udp_echoserver.c sntp_client.c ntp_run.c
  group FWLIB
    ../FWLIB/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
    ../FWLIB/STM32_ETH_Driver/src/: stm32_eth.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
